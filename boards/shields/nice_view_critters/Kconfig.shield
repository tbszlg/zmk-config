## boards/shields/nice_view_critters/Kconfig.shield
```kconfig
config SHIELD_NICE_VIEW_CRITTERS
    def_bool $(shields_list_contains,nice_view_critters)
```
